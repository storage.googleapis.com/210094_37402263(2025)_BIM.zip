Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 4ee71998-7a6e-489f-a289-5877b0e1d862, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 37402263(2025).ifc
Time: 2025-11-19T21:49:20+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_4912_1
InPort_4912_2

# IfcFlowTerminal: 37402263(2025):37402263 Washbasin faucet, 37402263(2025):37402263 Washbasin faucet:4912
In: Level 1
Type - Material: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 37402263(2025); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 37402263; Name: 37402263 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x185x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 175.338 mm; NominalHeight: 185.407 mm; NominalWidth: 45.9936 mm
Type - General - Author: BIMStone; BIMObjectName: 37402263(2025); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 2025/11/20
Type - Green Building Properties - EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/37402263; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/37402263
Type - Identity Data - 3D View: https://static.hansa.com/3D/37402263; Ambience photo: http://static.hansa.com/ambience/37402263; Catalog Drawing URL: http://static.hansa.com/catdrw/37402263; Category B2C: Washbasin; Color variants: 3740226333;3740226380;3740226381; Dimension Drawing URL: http://static.hansa.com/dimdrw/37402263; FDV Document URL: http://www.hansa.com/datasheet/37402263/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/37402263; Group: Washbasin faucet; Interactive AR View URL: https://static.hansa.com/AR/37402263; Manufacturer: HANSA; Market: International;Poland;Germany;Austria;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/37402263; Model: 37402263 Washbasin faucet; Name_en: 37402263 Washbasin faucet; OmniClass Number: 23.31.11.00; OmniClass Title: Faucets; Product Code: 37402263; Product Family: HANSAGENESIS; Product Image URL: http://static.hansa.com/image/37402263; Product URL: http://static.hansa.com/37402263; Spare-Part Information URL: http://static.hansa.com/sp/37402263; Technical DataSheet URL: http://www.hansa.com/datasheet/37402263/en; Type Name: 37402263 Washbasin faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Rapid installation system; Aerator: Hidden aerator;PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Push pop-up waste without draw-rod; Flow Rate At 300kPa With Flow Controller: 0.08 dm3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 90 C; Mechanical Parts: ø 30 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Spout Projection: 135 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 37402263; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 37402263 Washbasin faucet
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 37402263 Washbasin faucet; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 37402263(2025); Family and Type: 37402263(2025): 37402263 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 37402263 Washbasin faucet; Type Id: 4890; WarrantyStartDate: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0502004 m2; Volume: 0.00149991 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction
